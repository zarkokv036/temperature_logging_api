# Keil uVision project temperature_logging.uvprojx, settings and files
target temperature_logging (ARM-ADS)
  device: TM4C123GE6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: temperature_logging
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./src/: temperature_logging.h eeprom.h temperature_logging.c
software components: Device:Startup 1.0.1
